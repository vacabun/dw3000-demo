# Keil uVision project UWB-UAV-LABEL.uvprojx, settings and files
target UWB-UAV-LABEL (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: UWB-UAV-LABEL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Platform;../Drivers/Decawave/DW3000_API_C0_rev4p0;../Drivers/Decawave/DW3000_API_C0_rev4p0/examples;../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/examples_info;../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/shared_data;../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/MAC_802_15_4;../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/MAC_802_15_8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User/Platform
    ../Platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c printf.c
  group Users/Drivers/Decawave/DW3000_API_C0_rev4p0
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/: deca_device.c
  group Users/Drivers/Decawave/DW3000_API_C0_rev4p0/Examples/Common
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/: config_options.c
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/examples_info/: example_info.c
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/MAC_802_15_4/: mac_802_15_4.c
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/MAC_802_15_8/: mac_802_15_8.c
  group Users/Drivers/Decawave/DW3000_API_C0_rev4p0/Examples
    ../Drivers/Decawave/DW3000_API_C0_rev4p0/examples/ex_00a_reading_dev_id/: read_dev_id.c
software components: CMSIS:CORE 4.3.0
