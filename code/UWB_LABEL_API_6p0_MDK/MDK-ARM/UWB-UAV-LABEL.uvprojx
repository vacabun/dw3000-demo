# Keil uVision project UWB-UAV-LABEL.uvprojx, settings and files
target UWB-UAV-LABEL (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: UWB-UAV-LABEL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c misc: -fshort-enums
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/Decawave/DW3XXX_driver_6p0/Inc;../Platform;../Platform/deca;../Drivers/Decawave/example;../Drivers/Decawave/example/shared_data;../Drivers/Decawave/example/examples_info
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: UWB-UAV-LABEL\UWB-UAV-LABEL.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Platform
    ../Platform/: printf.c
  group Application/User/Platform/deca
    ../Platform/deca/: deca_mutex.c deca_probe_interface.c deca_sleep.c deca_spi.c deca_port.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/Decawave/DW3XXX_driver_6p0
    ../Drivers/Decawave/DW3XXX_driver_6p0/lib/: libdwt_uwb_driver-m4-hfp-6.0.7.a libdwt_uwb_driver-m4-sfp-6.0.7.a libdwt_uwb_driver-m33-hfp-6.0.7.a libdwt_uwb_driver-m33-sfp-6.0.7.a
  group Drivers/Decawave/DW3XXX_driver_6p0/example
    ../Drivers/Decawave/example/: config_options.c
    ../Drivers/Decawave/example/shared_data/: shared_functions.c
    ../Drivers/Decawave/example/examples_info/: example_info.c
    ../Drivers/Decawave/example/ex_00a_reading_dev_id/: read_dev_id.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
